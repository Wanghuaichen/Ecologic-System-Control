# Keil uVision project 电机调速.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 电机调速 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\I2C;.\SRC
  group Source Group 1
    ./: STARTUP.A51 电机调速.c
    ./SRC/: oled.c
    ./I2C/: i2c.c
