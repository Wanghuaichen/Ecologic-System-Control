# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC;.\I2C
  group Source Group 1
    ./: STARTUP.A51 main.c interrupt.c
    ./SRC/: oled.c
    ./I2C/: i2c.c
